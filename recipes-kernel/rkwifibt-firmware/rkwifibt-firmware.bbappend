FILES_${PN}-ap6359sa-wifi = " \
	system/etc/firmware/fw_bcm4359c0_ag.bin \
	system/etc/firmware/nvram_ap6398s.txt \
"
PACKAGES =+ "${PN}-ap6359sa-wifi"